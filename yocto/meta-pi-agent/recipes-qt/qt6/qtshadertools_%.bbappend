OECMAKE_CXX_FLAGS:append:class-native = " -w -std=c++17"
